# Keil uVision project lab01.uvproj, settings and files
target AT89S52 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: lab01 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\lib
  group src
    ./: STARTUP.A51 main.c
  group lib
    ../../lib/: utils.c types.h utils.h
