# Keil uVision project servo.uvproj, settings and files
target AT89S52 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: servo +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\lib
  group src
    ./: STARTUP.A51 main.c servo.c servo_config.h servo.h
  group lib
    ../lib/: utils.c utils.h types.h
