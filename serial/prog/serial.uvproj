# Keil uVision project serial.uvproj, settings and files
target AT89S52 (MCS-51)
  device: AT89S8253 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x2FFF) CLOCK(24000000) MODA2
  output: servo +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\lib
  group src
    ./: STARTUP.A51 main.c
  group lib
    ../../lib/: utils.c uart.c utils.h types.h uart.h
