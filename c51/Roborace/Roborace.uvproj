# Keil uVision project Roborace.uvproj, settings and files
target AT89S8252 (MCS-51)
  device: AT89S8252 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000) MODA2
  output: Roborace +hex
  c flags: Optimize=8 SizeSpeed=1
  group src
    ./: main.c config_tiny.a51 linescan.c config.h rangescan.c pwmgen.c types.h pwmgen.h motorctrl.h uart.c uart.h linescan.h
