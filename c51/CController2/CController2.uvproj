# Keil uVision project CController2.uvproj, settings and files
target AT89S82 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: CController2
  c flags: Optimize=8 SizeSpeed=1
  group src
    ./: STARTUP.A51 main.c CommandSM.c
