# Keil uVision project wireless.uvproj, settings and files
target mcu (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: wireless
  c flags: Optimize=8 SizeSpeed=1
  group src
    ./: main.c sw_uart.c sw_uart.h nrf24.h nrf24.c nrf_functions.c nRF24L01.h proto.h
