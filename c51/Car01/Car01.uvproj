# Keil uVision project Car01.uvproj, settings and files
target at89c2051 (MCS-51)
  device: AT89S8252 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000) MODA2
  output: Car01 +hex
  c flags: Optimize=8 SizeSpeed=1
  group src
    ./: STARTUP.A51 types.h main.c config.h
    ../lib/: pwm_bits.c pwm_bits.h uart.c uart.h
