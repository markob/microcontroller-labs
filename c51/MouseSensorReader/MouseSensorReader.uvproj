# Keil uVision project MouseSensorReader.uvproj, settings and files
target AT89S8252 (MCS-51)
  device: AT89C2051 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0x7FF) CLOCK(24000000)
  output: MouseSensorReader
  c flags: Optimize=8 SizeSpeed=1
  group src
    ./: STARTUP.A51 mouse.c types.h OptiMouse.c OptiMouse.h ADNS2610_DRV.h
