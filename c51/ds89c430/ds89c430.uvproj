# Keil uVision project ds89c430.uvproj, settings and files
target robocar (MCS-51)
  device: DS89C430 Dallas Semiconductor
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x3FFF) CLOCK(33000000) MODDP2
  output: ds89c430
  c flags: Optimize=8 SizeSpeed=1
  group src
    ./: START4XX.A51 main.c
