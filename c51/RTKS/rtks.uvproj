# Keil uVision project rtks.uvproj, settings and files
target AT89S52 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: rtks
  c flags: Optimize=8 SizeSpeed=1
  group kernel
    ./: rtks.a51
