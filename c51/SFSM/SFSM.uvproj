# Keil uVision project SFSM.uvproj, settings and files
target AT89S8252 (MCS-51)
  device: AT89S8252 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000) MODA2
  output: SFSM +hex
  c flags: Optimize=8 SizeSpeed=1
  group src
    ./: main.c STARTUP.A51
  group lib
    ./: sfsm.h types.h
