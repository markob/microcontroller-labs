# Keil uVision project SimpleTimer.uvproj, settings and files
target AT89C2951 (MCS-51)
  device: AT89C2051 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0x7FF) CLOCK(24000000)
  output: SimpleTimer +hex
  c flags: Optimize=8 SizeSpeed=1
  group src
    ./: main.c STARTUP.A51 types.h
